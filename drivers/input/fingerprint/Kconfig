## drivers/input/fingerprint/Kconfig
```kconfig
config BETTERLIFE_FINGERPRINT
  tristate "betterlife Fingerprint"
	help
	  betterlife fingerprint.
```
